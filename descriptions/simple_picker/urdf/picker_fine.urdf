Commit message: feat: position_sensor proto and python implement

File: descriptions/simple_picker/urdf/picker_fine.urdf (robot description, URDF)
Before this commit: robot picker, 5 links, 4 joints
Links:
- link link3_1: geometry collision box size=0.05 0.05 0.2; visual box size=0.05 0.05 0.2
